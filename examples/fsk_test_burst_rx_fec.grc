<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.14'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fsk_test_burst_rx_fec</value></param>
<param><key>author</key><value>Pavel Fiala</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>thread_safe_setters</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>demod_gain_mult</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dev</value></param>
<param><key>value</key><value>8e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>2.4e9-15e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>97.65625e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>smooth_len</value></param>
<param><key>value</key><value>4*50*smoth_length_mult</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>smoth_length_mult</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>variable_cc_decoder_def_rx</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>4096</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>[79,109]</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_TRUNCATED</value></param>
</block>
<block>
<key>AlteraSocSDR_altera_socfpga_sdr_source_complex</key>
<param><key>id</key><value>AlteraSocSDR_altera_socfpga_sdr_source_complex_0</value></param>
<param><key>AgcEnable</key><value>False</value></param>
<param><key>AnalogBw</key><value>200</value></param>
<param><key>BufferLength</key><value>134217728</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>DeviceName</key><value>/dev/altera_msgdma_rd0</value></param>
<param><key>DigitalBw</key><value>0_5</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>Frequency</key><value>100000000</value></param>
<param><key>RxGain</key><value>16</value></param>
<param><key>SampleRate</key><value>1000000</value></param>
<param><key>ScaleConstant</key><value>8192</value></param>
<param><key>ScaleFactor</key><value>True</value></param>
<param><key>swap_iq</key><value>True</value></param>
<param><key>WordLength</key><value>16</value></param>
</block>
<block>
<key>PacketDeCoderSDR_burst_fsk_bit_preamble_demap</key>
<param><key>id</key><value>PacketDeCoderSDR_burst_fsk_bit_preamble_demap_0</value></param>
<param><key>frameAlign</key><value>True</value></param>
<param><key>frameBlockSize</key><value>768</value></param>
<param><key>frameSkip</key><value>96</value></param>
<param><key>section</key><value>4</value></param>
<param><key>preamble_bits</key><value>pre_bits</value></param>
<param><key>shapeSoftBits</key><value>True</value></param>
<param><key>algorithm</key><value>0</value></param>
</block>
<block>
<key>PacketDeCoderSDR_burst_fsk_time_sync_c_plus</key>
<param><key>id</key><value>PacketDeCoderSDR_burst_fsk_time_sync_c_plus_0</value></param>
<param><key>n_freq_offset</key><value>True</value></param>
<param><key>n_offsets</key><value>8</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sps</key><value>8</value></param>
<param><key>upsample_rate</key><value>100.0</value></param>
</block>
<block>
<key>PacketDeCoderSDR_de_scrambler_additive</key>
<param><key>id</key><value>PacketDeCoderSDR_de_scrambler_additive_1</value></param>
<param><key>bits_per_byte</key><value>8</value></param>
<param><key>byteAppendOrder</key><value>0</value></param>
<param><key>regLength</key><value>8</value></param>
<param><key>mask</key><value>0xA9</value></param>
<param><key>seed</key><value>0xFF</value></param>
</block>
<block>
<key>PacketDeCoderSDR_decode_packet_1</key>
<param><key>id</key><value>PacketDeCoderSDR_decode_packet_1_0</value></param>
<param><key>dataPresentation</key><value>0</value></param>
<param><key>dataType</key><value>0</value></param>
<param><key>decodeHeader</key><value>True</value></param>
<param><key>filename</key><value></value></param>
<param><key>packetLength</key><value>64</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_1</value></param>
<param><key>gain</key><value>samp_rate/(2*math.pi*dev/(8*demod_gain_mult))</value></param>
</block>
<block>
<key>pyqt_time_plot</key>
<param><key>id</key><value>bits</value></param>
<param><key>l</key><value>Demod Bits</value></param>
<param><key>style</key><value>line</value></param>
</block>
<block>
<key>blocks_abs_xx</key>
<param><key>id</key><value>blocks_abs_xx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_abs_xx</key>
<param><key>id</key><value>blocks_abs_xx_0_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/tmp/fskburst.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0</value></param>
<param><key>length</key><value>smooth_len</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1.0/smooth_len</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>-1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_pdu_remove</key>
<param><key>id</key><value>blocks_pdu_remove_0</value></param>
<param><key>k</key><value>pmt.intern("es::event_buffer")</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_items</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>es_handler_pdu</key>
<param><key>id</key><value>es_handler_pdu_0</value></param>
<param><key>dt</key><value>es.es_handler_print.TYPE_F32</value></param>
</block>
<block>
<key>es_sink</key>
<param><key>id</key><value>es_sink_0</value></param>
<param><key>eb</key><value>discard</value></param>
<param><key>type</key><value>float</value></param>
<param><key>nthreads</key><value>8</value></param>
<param><key>num_streams</key><value>1</value></param>
<param><key>ss</key><value>forward</value></param>
<param><key>samplehistory</key><value>64</value></param>
<param><key>cb</key><value>drop</value></param>
</block>
<block>
<key>es_trigger_edge_f</key>
<param><key>id</key><value>es_trigger_edge_f_0</value></param>
<param><key>length</key><value>8000</value></param>
<param><key>lookback</key><value>smooth_len+10</value></param>
<param><key>guard</key><value>int(samp_rate * 0.1)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>thresh</key><value>-10</value></param>
</block>
<block>
<key>fec_async_decoder</key>
<param><key>id</key><value>fec_async_decoder_0</value></param>
<param><key>decoder</key><value>variable_cc_decoder_def_rx</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>mtu</key><value>1500</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_0</value></param>
<param><key>decim</key><value>decim</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>taps</key><value>firdes.low_pass(1.0, decim*samp_rate,100e3, 50e3)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>grnet_tcp_source</key>
<param><key>id</key><value>grnet_tcp_source_0</value></param>
<param><key>addr</key><value>192.168.85.149</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>server</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>port</key><value>2000</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>samp_rate/4</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>samp_rate/4</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>--&gt; 64 bytes packet (viterbi on) - 14k, 15k, 1536</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0</value></param>
<param><key>note</key><value>serial=31C92A4</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>--&gt; 64 bytes packet (viterbi off) - 8k, 10k, 768</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1_0</value></param>
<param><key>note</key><value>--&gt; 100 ms TX interval / 64 packet / Trigger 10</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1_1</value></param>
<param><key>note</key><value>addr=192.168.10.2</value></param>
</block>
<block>
<key>pdu_utils_pack_unpack</key>
<param><key>id</key><value>pdu_utils_pack_unpack_1</value></param>
<param><key>bit_order</key><value>pdu_utils.BIT_ORDER_MSB_FIRST</value></param>
<param><key>mode</key><value>pdu_utils.MODE_PACK_BYTE</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pre_bits</value></param>
<param><key>value</key><value>[0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 0, 1, 0, 1, 1, 0, 0, 1, 1, 1, 1, 1, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 1, 1, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 1, 0, 1, 0, 0, 1, 1, 1, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 1, 1, 0, 1, 0, 1, 0, 1, 1, 0, 0, 0]</value></param>
</block>
<block>
<key>pyqt_ctime_plot</key>
<param><key>id</key><value>pyqt_ctime_plot_0</value></param>
<param><key>l</key><value></value></param>
</block>
<block>
<key>pyqt_raster_plot</key>
<param><key>id</key><value>pyqt_raster_plot_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>l</key><value></value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>int(samp_rate/2)</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Detection Statistic"</value></param>
<param><key>size</key><value>int(samp_rate/2)</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>FSK demod</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_1</value></param>
<param><key>alpha</key><value>0.35</value></param>
<param><key>decim</key><value>4</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>ntaps</key><value>41</value></param>
<param><key>samp_rate</key><value>4*samp_rate</value></param>
<param><key>sym_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>satellites_decode_rs</key>
<param><key>id</key><value>satellites_decode_rs_0</value></param>
<param><key>basis</key><value>0</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>60</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>serial=31C92A4</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sd_spec0</key><value>A:A</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate*4</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>start_time</key><value>-1</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>AlteraSocSDR_altera_socfpga_sdr_source_complex_0</source_block_id><sink_block_id>root_raised_cosine_filter_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PacketDeCoderSDR_burst_fsk_bit_preamble_demap_0</source_block_id><sink_block_id>pdu_utils_pack_unpack_1</sink_block_id><source_key>fpdus_hard</source_key><sink_key>pdu_in</sink_key></connection>
<connection><source_block_id>PacketDeCoderSDR_burst_fsk_bit_preamble_demap_0</source_block_id><sink_block_id>fec_async_decoder_0</sink_block_id><source_key>fpdus_soft</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>PacketDeCoderSDR_burst_fsk_time_sync_c_plus_0</source_block_id><sink_block_id>PacketDeCoderSDR_burst_fsk_bit_preamble_demap_0</sink_block_id><source_key>fpdus_out</source_key><sink_key>fpdus</sink_key></connection>
<connection><source_block_id>PacketDeCoderSDR_burst_fsk_time_sync_c_plus_0</source_block_id><sink_block_id>bits</sink_block_id><source_key>fpdus_out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>PacketDeCoderSDR_burst_fsk_time_sync_c_plus_0</source_block_id><sink_block_id>pyqt_raster_plot_0</sink_block_id><source_key>fpdus_out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>PacketDeCoderSDR_de_scrambler_additive_1</source_block_id><sink_block_id>PacketDeCoderSDR_decode_packet_1_0</sink_block_id><source_key>out_pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>PacketDeCoderSDR_decode_packet_1_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out_pdus</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_1</source_block_id><sink_block_id>blocks_abs_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_1</source_block_id><sink_block_id>blocks_skiphead_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_1</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_1</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_1</source_block_id><sink_block_id>qtgui_time_sink_x_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_abs_xx_0</source_block_id><sink_block_id>blocks_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_abs_xx_0_0</source_block_id><sink_block_id>blocks_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>root_raised_cosine_filter_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>es_trigger_edge_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_remove_0</source_block_id><sink_block_id>PacketDeCoderSDR_burst_fsk_time_sync_c_plus_0</sink_block_id><source_key>pdus</source_key><sink_key>fpdus</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>blocks_abs_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>es_handler_pdu_0</source_block_id><sink_block_id>blocks_pdu_remove_0</sink_block_id><source_key>pdus_out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>es_handler_pdu_0</source_block_id><sink_block_id>pyqt_ctime_plot_0</sink_block_id><source_key>pdus_out</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>es_trigger_edge_f_0</source_block_id><sink_block_id>es_handler_pdu_0</sink_block_id><source_key>edge_event</source_key><sink_key>handle_event</sink_key></connection>
<connection><source_block_id>es_trigger_edge_f_0</source_block_id><sink_block_id>es_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>es_trigger_edge_f_0</source_block_id><sink_block_id>es_sink_0</sink_block_id><source_key>which_stream</source_key><sink_key>schedule_event</sink_key></connection>
<connection><source_block_id>fec_async_decoder_0</source_block_id><sink_block_id>pdu_utils_pack_unpack_1</sink_block_id><source_key>out</source_key><sink_key>pdu_in</sink_key></connection>
<connection><source_block_id>grnet_tcp_source_0</source_block_id><sink_block_id>root_raised_cosine_filter_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>es_trigger_edge_f_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pdu_utils_pack_unpack_1</source_block_id><sink_block_id>satellites_decode_rs_0</sink_block_id><source_key>pdu_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_1</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satellites_decode_rs_0</source_block_id><sink_block_id>PacketDeCoderSDR_de_scrambler_additive_1</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>root_raised_cosine_filter_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
