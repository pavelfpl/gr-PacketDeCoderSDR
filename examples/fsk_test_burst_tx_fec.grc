<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.14'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fsk_test_burst_tx_fec</value></param>
<param><key>author</key><value>Pavel Fiala</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_command</key><value>{python} -u {filename} </value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_rate</value></param>
<param><key>value</key><value>samp_rate/8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dev</value></param>
<param><key>value</key><value>samp_rate/8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>865e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>interp</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>alpha</key><value>0.35</value></param>
<param><key>gain</key><value>4</value></param>
<param><key>ntaps</key><value>61</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sym_rate</key><value>dev*2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>97.65625e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>samp_rate/data_rate</value></param>
</block>
<block>
<key>variable_cc_encoder_def</key>
<param><key>id</key><value>variable_cc_encoder_def_tx</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>framebits</key><value>4096</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>[79,109]</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_TRUNCATED</value></param>
</block>
<block>
<key>AlteraSocSDR_altera_socfpga_sdr_sink_complex</key>
<param><key>id</key><value>AlteraSocSDR_altera_socfpga_sdr_sink_complex_0</value></param>
<param><key>AnalogBw</key><value>80</value></param>
<param><key>BufferLength</key><value>134217728</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>DeviceName</key><value>/dev/altera_msgdma_wr0</value></param>
<param><key>DigitalBw</key><value>0_5</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>Frequency</key><value>100000000</value></param>
<param><key>gainCorrection</key><value>1.0</value></param>
<param><key>oversampleRatio</key><value>8</value></param>
<param><key>SampleRate</key><value>samp_rate</value></param>
<param><key>ScaleConstant</key><value>8192</value></param>
<param><key>ScaleFactor</key><value>True</value></param>
<param><key>swap_iq</key><value>False</value></param>
<param><key>TxGain</key><value>16</value></param>
<param><key>WordLength</key><value>16</value></param>
</block>
<block>
<key>PacketDeCoderSDR_build_packet_1</key>
<param><key>id</key><value>PacketDeCoderSDR_build_packet_1_0</value></param>
<param><key>appendHeader</key><value>True</value></param>
<param><key>dataFrom</key><value>0</value></param>
<param><key>dataType</key><value>0</value></param>
<param><key>filename</key><value>/home/pavelf/aries-mcv-jtag-chain.jpeg</value></param>
<param><key>packet_bytes_h</key><value>[0x00,0x01,0x02,0x03,0x04,0x05,0x06,0x07]</value></param>
<param><key>packetLength</key><value>64</value></param>
</block>
<block>
<key>PacketDeCoderSDR_de_scrambler_additive</key>
<param><key>id</key><value>PacketDeCoderSDR_de_scrambler_additive_0</value></param>
<param><key>bits_per_byte</key><value>8</value></param>
<param><key>byteAppendOrder</key><value>0</value></param>
<param><key>regLength</key><value>8</value></param>
<param><key>mask</key><value>0xA9</value></param>
<param><key>seed</key><value>0xFF</value></param>
</block>
<block>
<key>PacketDeCoderSDR_fsk_burst_modulator</key>
<param><key>id</key><value>PacketDeCoderSDR_fsk_burst_modulator_0</value></param>
<param><key>dev</key><value>dev</value></param>
<param><key>taps</key><value>[0.000003984201397,0.000013787809353,0.000044041806845,0.000129852662229,0.000353388538458,0.000887707590789,0.002058274431450,0.004405066779438,0.008701970082519,0.015867136102758,0.026705172029971,0.041486622997972,0.059488999027626,0.078737407290814,0.096192548368404,0.108471993725238,0.112904093109483,0.108471993725238,0.096192548368404,0.078737407290814,0.059488999027626,0.041486622997972,0.026705172029971,0.015867136102758,0.008701970082519,0.004405066779438,0.002058274431450,0.000887707590789,0.000353388538458,0.000129852662229,0.000044041806845,0.000013787809353,0.000003984201397]</value></param>
<param><key>fskType</key><value>2</value></param>
<param><key>sampRate</key><value>samp_rate</value></param>
<param><key>sps</key><value>8</value></param>
<param><key>sensitivity</key><value>0.1963495405*4</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/tmp/fskburst.dat</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("SEND")</value></param>
<param><key>period</key><value>200</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>interp*samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>burst_preamble_insert</key>
<param><key>id</key><value>burst_preamble_insert_0</value></param>
<param><key>pre</key><value>pre_bits</value></param>
</block>
<block>
<key>burst_scheduler</key>
<param><key>id</key><value>burst_scheduler_0</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>epsilon</key><value>1-1e-6*numpy.random.normal(0,1)</value></param>
<param><key>freq_offset</key><value>1e-5*numpy.random.normal(0,1)</value></param>
<param><key>noise_voltage</key><value>0.220*1.2</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>1</value></param>
</block>
<block>
<key>es_source</key>
<param><key>id</key><value>es_source_0</value></param>
<param><key>eb</key><value>discard</value></param>
<param><key>nthreads</key><value>4</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>mm</key><value>memcpy</value></param>
<param><key>num_streams</key><value>1</value></param>
</block>
<block>
<key>fec_async_encoder</key>
<param><key>id</key><value>fec_async_encoder_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>encoder</key><value>variable_cc_encoder_def_tx</value></param>
<param><key>mtu</key><value>1500</value></param>
</block>
<block>
<key>grnet_tcp_sink</key>
<param><key>id</key><value>grnet_tcp_sink_0</value></param>
<param><key>addr</key><value>127.0.0.1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>mode</key><value>2</value></param>
<param><key>port</key><value>2000</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>interp</key><value>interp</value></param>
<param><key>taps</key><value>rrc_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>bits to syms</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0</value></param>
<param><key>note</key><value>interp samp/sym</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0</value></param>
<param><key>note</key><value>fsk mod</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>Default: samp_rate = 100k or 50M/128/4 = 97.65625k</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2</value></param>
<param><key>note</key><value>For default sample rate: sps = 12.5k; data_rate =12.5k </value></param>
</block>
<block>
<key>pdu_utils_pack_unpack</key>
<param><key>id</key><value>pdu_utils_pack_unpack_0</value></param>
<param><key>bit_order</key><value>pdu_utils.BIT_ORDER_MSB_FIRST</value></param>
<param><key>mode</key><value>pdu_utils.MODE_UNPACK_BYTE</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pre_bits</value></param>
<param><key>value</key><value>[0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 0, 1, 0, 1, 1, 0, 0, 1, 1, 1, 1, 1, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 1, 1, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 1, 0, 1, 0, 0, 1, 1, 1, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 1, 1, 0, 1, 0, 1, 0, 1, 1, 0, 0, 0]</value></param>
</block>
<block>
<key>pyqt_cpsd_plot</key>
<param><key>id</key><value>pyqt_cpsd_plot_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>l</key><value></value></param>
</block>
<block>
<key>pyqt_ctime_plot</key>
<param><key>id</key><value>pyqt_ctime_plot_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>l</key><value></value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate*interp</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>int((interp*samp_rate)/2)</value></param>
<param><key>srate</key><value>interp*samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>satellites_encode_rs</key>
<param><key>id</key><value>satellites_encode_rs_0</value></param>
<param><key>basis</key><value>0</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>addr=192.168.10.2</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate*4</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>False</value></param>
<param><key>start_time</key><value>-1</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<connection><source_block_id>PacketDeCoderSDR_build_packet_1_0</source_block_id><sink_block_id>PacketDeCoderSDR_de_scrambler_additive_0</sink_block_id><source_key>out_pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>PacketDeCoderSDR_de_scrambler_additive_0</source_block_id><sink_block_id>satellites_encode_rs_0</sink_block_id><source_key>out_pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>PacketDeCoderSDR_fsk_burst_modulator_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>cfpdus</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>PacketDeCoderSDR_fsk_burst_modulator_0</source_block_id><sink_block_id>burst_scheduler_0</sink_block_id><source_key>cfpdus</source_key><sink_key>sched_pdu</sink_key></connection>
<connection><source_block_id>PacketDeCoderSDR_fsk_burst_modulator_0</source_block_id><sink_block_id>pyqt_cpsd_plot_0</sink_block_id><source_key>cfpdus</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>PacketDeCoderSDR_fsk_burst_modulator_0</source_block_id><sink_block_id>pyqt_ctime_plot_0</sink_block_id><source_key>cfpdus</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>PacketDeCoderSDR_build_packet_1_0</sink_block_id><source_key>strobe</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>burst_preamble_insert_0</source_block_id><sink_block_id>PacketDeCoderSDR_fsk_burst_modulator_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>burst_scheduler_0</source_block_id><sink_block_id>es_source_0</sink_block_id><source_key>sched_pdu</source_key><sink_key>schedule_event</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>es_source_0</source_block_id><sink_block_id>burst_scheduler_0</sink_block_id><source_key>nproduced</source_key><sink_key>nproduced</sink_key></connection>
<connection><source_block_id>es_source_0</source_block_id><sink_block_id>AlteraSocSDR_altera_socfpga_sdr_sink_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>es_source_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_async_encoder_0</source_block_id><sink_block_id>burst_preamble_insert_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>grnet_tcp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pdu_utils_pack_unpack_0</source_block_id><sink_block_id>fec_async_encoder_0</sink_block_id><source_key>pdu_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satellites_encode_rs_0</source_block_id><sink_block_id>pdu_utils_pack_unpack_0</sink_block_id><source_key>out</source_key><sink_key>pdu_in</sink_key></connection>
</flow_graph>
