<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>psk_burst_rx_fec</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>2.4e9-0e3</value></param>
</block>
<block>
<key>variable_ldpc_decoder_def</key>
<param><key>id</key><value>ldpc_dec</value></param>
<param><key>file</key><value>/home/pavelf/build_sockit_arm/gnuradio_socfpga/grc_flowcharts/271.127.3.112</value></param>
<param><key>max_iter</key><value>50</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>sigma</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>97.65625e3</value></param>
</block>
<block>
<key>AlteraSocSDR_altera_socfpga_sdr_source_complex</key>
<param><key>id</key><value>AlteraSocSDR_altera_socfpga_sdr_source_complex_0</value></param>
<param><key>BufferLength</key><value>134217728</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>DeviceName</key><value>/dev/altera_msgdma_rd0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>Frequency</key><value>100000000</value></param>
<param><key>GainIF</key><value>0</value></param>
<param><key>GainRF</key><value>0</value></param>
<param><key>SampleRate</key><value>1000000</value></param>
<param><key>ScaleConstant</key><value>8192</value></param>
<param><key>ScaleFactor</key><value>True</value></param>
<param><key>swap_iq</key><value>True</value></param>
<param><key>WordLength</key><value>16</value></param>
</block>
<block>
<key>PacketDeCoderSDR_de_scrambler_additive</key>
<param><key>id</key><value>PacketDeCoderSDR_de_scrambler_additive_1</value></param>
<param><key>bits_per_byte</key><value>8</value></param>
<param><key>byteAppendOrder</key><value>0</value></param>
<param><key>regLength</key><value>8</value></param>
<param><key>mask</key><value>0xA9</value></param>
<param><key>seed</key><value>0xFF</value></param>
</block>
<block>
<key>PacketDeCoderSDR_decode_packet_1</key>
<param><key>id</key><value>PacketDeCoderSDR_decode_packet_1_0</value></param>
<param><key>dataPresentation</key><value>0</value></param>
<param><key>dataType</key><value>0</value></param>
<param><key>decodeHeader</key><value>True</value></param>
<param><key>filename</key><value></value></param>
<param><key>packetLength</key><value>144</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/tmp/psk_ldpc_xmit.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate*2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>burst_correlator_filter</key>
<param><key>id</key><value>burst_correlator_filter_0</value></param>
<param><key>l1</key><value>100*2</value></param>
<param><key>thresh</key><value>-10</value></param>
<param><key>i1</key><value>1e-4</value></param>
</block>
<block>
<key>burst_deframer</key>
<param><key>id</key><value>burst_deframer_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>burst_framealign</key>
<param><key>id</key><value>burst_framealign_0</value></param>
<param><key>bs</key><value>271</value></param>
<param><key>skip</key><value>len(pre_bits)</value></param>
</block>
<block>
<key>burst_length_detect_c</key>
<param><key>id</key><value>burst_length_detect_c_0</value></param>
</block>
<block>
<key>burst_preamble_correlator</key>
<param><key>id</key><value>burst_preamble_correlator_0</value></param>
<param><key>pre</key><value>pre_bits</value></param>
<param><key>ro</key><value>0.35</value></param>
<param><key>sps</key><value>4</value></param>
</block>
<block>
<key>burst_randomizer</key>
<param><key>id</key><value>burst_randomizer_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>iv</key><value>[1,0,0,1,0,1,0,1,0,0,0,0,0,0,0]</value></param>
<param><key>ml</key><value>100000</value></param>
<param><key>p</key><value>[0,14,15]</value></param>
</block>
<block>
<key>burst_slicer</key>
<param><key>id</key><value>burst_slicer_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>burst_synchronizer_v4</key>
<param><key>id</key><value>burst_synchronizer_v4_0</value></param>
<param><key>burst_size</key><value>4096*2</value></param>
<param><key>pll_type</key><value>2</value></param>
<param><key>taps_</key><value>[0.0018798966193571687, -0.0005957852699793875, -0.002913221251219511, -0.002573465695604682, 0.0005119061679579318, 0.003337589092552662, 0.002398500684648752, -0.0023926629219204187, -0.006377795245498419, -0.0037021359894424677, 0.0064182160422205925, 0.016373006626963615, 0.01431208848953247, -0.00553062604740262, -0.03386737033724785, -0.047264810651540756, -0.02122040092945099, 0.05183464661240578, 0.15228667855262756, 0.23982208967208862, 0.27452731132507324, 0.23982208967208862, 0.15228667855262756, 0.05183464661240578, -0.02122040092945099, -0.047264810651540756, -0.03386737033724785, -0.00553062604740262, 0.01431208848953247, 0.016373006626963615, 0.0064182160422205925, -0.0037021359894424677, -0.006377795245498419, -0.0023926629219204187, 0.002398500684648752, 0.003337589092552662, 0.0005119061679579318, -0.002573465695604682, -0.002913221251219511, -0.0005957852699793875, 0.0018798966193571687] </value></param>
<param><key>decimation</key><value>2</value></param>
<param><key>decim</key><value>True</value></param>
<param><key>port_debug</key><value>True</value></param>
<param><key>preamble_bits</key><value>pre_bits</value></param>
<param><key>fs</key><value>samp_rate*2</value></param>
<param><key>sps</key><value>2</value></param>
<param><key>sym_mapping</key><value>[0,1,3,2]</value></param>
</block>
<block>
<key>es_handler_pdu</key>
<param><key>id</key><value>es_handler_pdu_0</value></param>
<param><key>dt</key><value>es.es_handler_print.TYPE_C32</value></param>
</block>
<block>
<key>es_sink</key>
<param><key>id</key><value>es_sink_0</value></param>
<param><key>eb</key><value>discard</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>nthreads</key><value>8</value></param>
<param><key>num_streams</key><value>1</value></param>
<param><key>ss</key><value>binary</value></param>
<param><key>samplehistory</key><value>64</value></param>
<param><key>cb</key><value>drop</value></param>
</block>
<block>
<key>es_trigger_edge_f</key>
<param><key>id</key><value>es_trigger_edge_f_0</value></param>
<param><key>length</key><value>1024*4*2</value></param>
<param><key>lookback</key><value>100*2</value></param>
<param><key>guard</key><value>500*2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>thresh</key><value>5</value></param>
</block>
<block>
<key>fec_async_decoder</key>
<param><key>id</key><value>fec_async_decoder_0</value></param>
<param><key>decoder</key><value>ldpc_dec</value></param>
<param><key>mtu</key><value>1500</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>decim</key><value>decim</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>taps</key><value>firdes.low_pass(1.0, decim*samp_rate,100e3, 10e3)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>grnet_tcp_source</key>
<param><key>id</key><value>grnet_tcp_source_0</value></param>
<param><key>addr</key><value>192.168.85.149</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>server</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>port</key><value>2000</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>mapper_demapper_msg</key>
<param><key>id</key><value>mapper_demapper_msg_0</value></param>
<param><key>modtype</key><value>mapper.QPSK</value></param>
<param><key>symbol_values</key><value>[0,1,3,2]</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>serial=31C92A4</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>addr=192.168.10.2</value></param>
</block>
<block>
<key>pdu_utils_pack_unpack</key>
<param><key>id</key><value>pdu_utils_pack_unpack_1</value></param>
<param><key>bit_order</key><value>pdu_utils.BIT_ORDER_MSB_FIRST</value></param>
<param><key>mode</key><value>pdu_utils.MODE_PACK_BYTE</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pre_bits</value></param>
<param><key>value</key><value>[0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 0, 1, 0, 1, 1, 0, 0, 1, 1, 1, 1, 1, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 1, 1, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 1, 0, 1, 0, 0, 1, 1, 1, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 1, 1, 0, 1, 0, 1, 0, 1, 1, 0, 0, 0]</value></param>
</block>
<block>
<key>pyqt_const_plot</key>
<param><key>id</key><value>pyqt_const_plot_0</value></param>
<param><key>gui_hint</key><value>2,0</value></param>
<param><key>l</key><value>Pre-Sync Syms</value></param>
</block>
<block>
<key>pyqt_const_plot</key>
<param><key>id</key><value>pyqt_const_plot_0_0</value></param>
<param><key>gui_hint</key><value>2,2</value></param>
<param><key>l</key><value>Final Syms</value></param>
</block>
<block>
<key>pyqt_const_plot</key>
<param><key>id</key><value>pyqt_const_plot_0_0_0</value></param>
<param><key>gui_hint</key><value>2,1</value></param>
<param><key>l</key><value>Sym CFO Corr</value></param>
</block>
<block>
<key>pyqt_cpower_plot</key>
<param><key>id</key><value>pyqt_cpower_plot_0</value></param>
<param><key>gui_hint</key><value>1,0</value></param>
<param><key>l</key><value>Burst Envelope</value></param>
</block>
<block>
<key>pyqt_cpower_plot</key>
<param><key>id</key><value>pyqt_cpower_plot_0_0</value></param>
<param><key>gui_hint</key><value>1,1,1,2</value></param>
<param><key>l</key><value>Burst Post Length-D</value></param>
</block>
<block>
<key>pyqt_cpower_plot</key>
<param><key>id</key><value>pyqt_cpower_plot_0_2</value></param>
<param><key>gui_hint</key><value>4,2,1,1</value></param>
<param><key>l</key><value>Final Syms</value></param>
</block>
<block>
<key>pyqt_meta_text_output</key>
<param><key>id</key><value>pyqt_meta_text_output_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>0,2</value></param>
</block>
<block>
<key>pyqt_time_plot</key>
<param><key>id</key><value>pyqt_time_plot_1</value></param>
<param><key>gui_hint</key><value>4,0</value></param>
<param><key>l</key><value>XCorr Mags</value></param>
<param><key>style</key><value>line</value></param>
</block>
<block>
<key>pyqt_time_plot</key>
<param><key>id</key><value>pyqt_time_plot_1_0</value></param>
<param><key>gui_hint</key><value>4,1,1,1</value></param>
<param><key>l</key><value>Soft Bits</value></param>
<param><key>style</key><value>dots</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>0,0,1,2</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value></value></param>
<param><key>size</key><value>8192*16</value></param>
<param><key>srate</key><value>samp_rate*2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ylabel</key><value></value></param>
<param><key>yunit</key><value></value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>32768*4</value></param>
<param><key>srate</key><value>samp_rate*2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_1</value></param>
<param><key>alpha</key><value>0.35</value></param>
<param><key>decim</key><value>2</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>ntaps</key><value>41</value></param>
<param><key>samp_rate</key><value>4*samp_rate</value></param>
<param><key>sym_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>50</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>serial=31C92A4</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>sd_spec0</key><value>A:A</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate*4</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>AlteraSocSDR_altera_socfpga_sdr_source_complex_0</source_block_id><sink_block_id>root_raised_cosine_filter_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PacketDeCoderSDR_de_scrambler_additive_1</source_block_id><sink_block_id>PacketDeCoderSDR_decode_packet_1_0</sink_block_id><source_key>out_pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>PacketDeCoderSDR_decode_packet_1_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out_pdus</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>root_raised_cosine_filter_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>burst_preamble_correlator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>es_trigger_edge_f_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>burst_correlator_filter_0</source_block_id><sink_block_id>es_trigger_edge_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>burst_correlator_filter_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>burst_deframer_0</source_block_id><sink_block_id>pyqt_meta_text_output_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>burst_framealign_0</source_block_id><sink_block_id>burst_slicer_0</sink_block_id><source_key>fpdus</source_key><sink_key>fpdus</sink_key></connection>
<connection><source_block_id>burst_framealign_0</source_block_id><sink_block_id>fec_async_decoder_0</sink_block_id><source_key>fpdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>burst_length_detect_c_0</source_block_id><sink_block_id>burst_synchronizer_v4_0</sink_block_id><source_key>cpdus</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>burst_length_detect_c_0</source_block_id><sink_block_id>pyqt_const_plot_0</sink_block_id><source_key>cpdus</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>burst_length_detect_c_0</source_block_id><sink_block_id>pyqt_cpower_plot_0_0</sink_block_id><source_key>cpdus</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>burst_preamble_correlator_0</source_block_id><sink_block_id>burst_correlator_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>burst_randomizer_0</source_block_id><sink_block_id>burst_deframer_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>burst_slicer_0</source_block_id><sink_block_id>burst_randomizer_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>burst_synchronizer_v4_0</source_block_id><sink_block_id>mapper_demapper_msg_0</sink_block_id><source_key>cpdus</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>burst_synchronizer_v4_0</source_block_id><sink_block_id>pyqt_const_plot_0_0</sink_block_id><source_key>cpdus</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>burst_synchronizer_v4_0</source_block_id><sink_block_id>pyqt_cpower_plot_0_2</sink_block_id><source_key>cpdus</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>burst_synchronizer_v4_0</source_block_id><sink_block_id>pyqt_const_plot_0_0_0</sink_block_id><source_key>debug_post_cfo</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>burst_synchronizer_v4_0</source_block_id><sink_block_id>pyqt_time_plot_1</sink_block_id><source_key>debug_pre_xcorr</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>es_handler_pdu_0</source_block_id><sink_block_id>burst_length_detect_c_0</sink_block_id><source_key>pdus_out</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>es_handler_pdu_0</source_block_id><sink_block_id>pyqt_cpower_plot_0</sink_block_id><source_key>pdus_out</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>es_trigger_edge_f_0</source_block_id><sink_block_id>es_handler_pdu_0</sink_block_id><source_key>edge_event</source_key><sink_key>handle_event</sink_key></connection>
<connection><source_block_id>es_trigger_edge_f_0</source_block_id><sink_block_id>es_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>es_trigger_edge_f_0</source_block_id><sink_block_id>es_sink_0</sink_block_id><source_key>which_stream</source_key><sink_key>schedule_event</sink_key></connection>
<connection><source_block_id>fec_async_decoder_0</source_block_id><sink_block_id>burst_randomizer_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>fec_async_decoder_0</source_block_id><sink_block_id>pdu_utils_pack_unpack_1</sink_block_id><source_key>out</source_key><sink_key>pdu_in</sink_key></connection>
<connection><source_block_id>grnet_tcp_source_0</source_block_id><sink_block_id>root_raised_cosine_filter_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mapper_demapper_msg_0</source_block_id><sink_block_id>burst_framealign_0</sink_block_id><source_key>fpdus</source_key><sink_key>fpdus</sink_key></connection>
<connection><source_block_id>mapper_demapper_msg_0</source_block_id><sink_block_id>pyqt_time_plot_1_0</sink_block_id><source_key>fpdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>pdu_utils_pack_unpack_1</source_block_id><sink_block_id>PacketDeCoderSDR_de_scrambler_additive_1</sink_block_id><source_key>pdu_out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_1</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>root_raised_cosine_filter_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
