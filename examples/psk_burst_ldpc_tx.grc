<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>psk_burst_tx</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>2.4e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>interp</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable_ldpc_encoder_def</key>
<param><key>id</key><value>ldpc_enc</value></param>
<param><key>file</key><value>/home/pavelf/build_sockit_arm/gnuradio_socfpga/grc_flowcharts/271.127.3.112</value></param>
<param><key>ndim</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>97.65625e3</value></param>
</block>
<block>
<key>AlteraSocSDR_altera_socfpga_sdr_sink_complex</key>
<param><key>id</key><value>AlteraSocSDR_altera_socfpga_sdr_sink_complex_0</value></param>
<param><key>BufferLength</key><value>134217728</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>DeviceName</key><value>/dev/altera_msgdma_wr0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>Frequency</key><value>100000000</value></param>
<param><key>gainCorrection</key><value>1.0</value></param>
<param><key>GainIF</key><value>0</value></param>
<param><key>GainRF</key><value>0</value></param>
<param><key>SampleRate</key><value>1000000</value></param>
<param><key>ScaleConstant</key><value>8192</value></param>
<param><key>ScaleFactor</key><value>True</value></param>
<param><key>swap_iq</key><value>False</value></param>
<param><key>WordLength</key><value>16</value></param>
</block>
<block>
<key>PacketDeCoderSDR_build_packet_1</key>
<param><key>id</key><value>PacketDeCoderSDR_build_packet_1_0</value></param>
<param><key>appendHeader</key><value>True</value></param>
<param><key>dataFrom</key><value>0</value></param>
<param><key>dataType</key><value>0</value></param>
<param><key>filename</key><value></value></param>
<param><key>packetLength</key><value>144</value></param>
</block>
<block>
<key>PacketDeCoderSDR_de_scrambler_additive</key>
<param><key>id</key><value>PacketDeCoderSDR_de_scrambler_additive_0</value></param>
<param><key>bits_per_byte</key><value>8</value></param>
<param><key>byteAppendOrder</key><value>0</value></param>
<param><key>regLength</key><value>8</value></param>
<param><key>mask</key><value>0xA9</value></param>
<param><key>seed</key><value>0xFF</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/tmp/psk_ldpc_xmit.dat</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>250</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0</value></param>
<param><key>mask</key><value>0xFF</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>length_modulo</key><value>2</value></param>
<param><key>maxsize</key><value>256/2</value></param>
<param><key>minsize</key><value>50</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>interp*samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate/2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>burst_framer</key>
<param><key>id</key><value>burst_framer_0</value></param>
<param><key>bs</key><value>144</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>burst_padder</key>
<param><key>id</key><value>burst_padder_0</value></param>
<param><key>blocksize</key><value>144</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>burst_preamble_insert</key>
<param><key>id</key><value>burst_preamble_insert_0</value></param>
<param><key>pre</key><value>pre_bits</value></param>
</block>
<block>
<key>burst_randomizer</key>
<param><key>id</key><value>burst_randomizer_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>iv</key><value>[1,0,0,1,0,1,0,1,0,0,0,0,0,0,0]</value></param>
<param><key>ml</key><value>100000</value></param>
<param><key>p</key><value>[0,14,15]</value></param>
</block>
<block>
<key>burst_scheduler</key>
<param><key>id</key><value>burst_scheduler_0</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0_0</value></param>
<param><key>epsilon</key><value>1.0+random.random()*1e-4</value></param>
<param><key>freq_offset</key><value>-0.06</value></param>
<param><key>noise_voltage</key><value>0.2</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>1.0 + 1.0j</value></param>
</block>
<block>
<key>es_source</key>
<param><key>id</key><value>es_source_0</value></param>
<param><key>eb</key><value>asap</value></param>
<param><key>nthreads</key><value>8</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>mm</key><value>memcpy</value></param>
<param><key>num_streams</key><value>1</value></param>
</block>
<block>
<key>fec_async_encoder</key>
<param><key>id</key><value>fec_async_encoder_0</value></param>
<param><key>encoder</key><value>ldpc_enc</value></param>
<param><key>mtu</key><value>1500</value></param>
</block>
<block>
<key>grnet_tcp_sink</key>
<param><key>id</key><value>grnet_tcp_sink_0</value></param>
<param><key>addr</key><value>127.0.0.1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>mode</key><value>2</value></param>
<param><key>port</key><value>2000</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import random</value></param>
</block>
<block>
<key>mapper_mapper_msg</key>
<param><key>id</key><value>mapper_mapper_msg_0</value></param>
<param><key>modtype</key><value>mapper.QPSK</value></param>
<param><key>symbol_values</key><value>[0,1,3,2]</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>Symbol rate 25: interp 16; gain 4; Num taps 41 or 61</value></param>
</block>
<block>
<key>pdu_utils_pack_unpack</key>
<param><key>id</key><value>pdu_utils_pack_unpack_0</value></param>
<param><key>bit_order</key><value>pdu_utils.BIT_ORDER_MSB_FIRST</value></param>
<param><key>mode</key><value>pdu_utils.MODE_UNPACK_BYTE</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pre_bits</value></param>
<param><key>value</key><value>[0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 0, 1, 0, 1, 1, 0, 0, 1, 1, 1, 1, 1, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 1, 1, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 1, 0, 1, 0, 0, 1, 1, 1, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 1, 1, 0, 1, 0, 1, 0, 1, 1, 0, 0, 0]</value></param>
</block>
<block>
<key>pyqt_ctime_plot</key>
<param><key>id</key><value>pyqt_ctime_plot_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>1,0</value></param>
<param><key>l</key><value></value></param>
</block>
<block>
<key>pyqt_meta_text_output</key>
<param><key>id</key><value>pyqt_meta_text_output_0</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>1,1</value></param>
<param><key>size</key><value>interp*8192</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>0,0,1,0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>interp*8192</value></param>
<param><key>srate</key><value>interp*samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_0</value></param>
<param><key>alpha</key><value>0.35</value></param>
<param><key>type</key><value>interp_fir_filter_ccf</value></param>
<param><key>gain</key><value>gain</value></param>
<param><key>interp</key><value>2*interp</value></param>
<param><key>ntaps</key><value>121</value></param>
<param><key>samp_rate</key><value>samp_rate*4</value></param>
<param><key>sym_rate</key><value>samp_rate/2</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_0_0</value></param>
<param><key>alpha</key><value>0.35</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>interp_fir_filter_ccf</value></param>
<param><key>gain</key><value>gain</value></param>
<param><key>interp</key><value>2*interp</value></param>
<param><key>ntaps</key><value>41</value></param>
<param><key>samp_rate</key><value>interp*4.0*25e3</value></param>
<param><key>sym_rate</key><value>2*25e3</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>50</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>serial=31C92A4</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sd_spec0</key><value>A:A</value></param>
<param><key>samp_rate</key><value>4*samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<connection><source_block_id>PacketDeCoderSDR_build_packet_1_0</source_block_id><sink_block_id>PacketDeCoderSDR_de_scrambler_additive_0</sink_block_id><source_key>out_pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>PacketDeCoderSDR_de_scrambler_additive_0</source_block_id><sink_block_id>pdu_utils_pack_unpack_0</sink_block_id><source_key>out_pdus</source_key><sink_key>pdu_in</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>PacketDeCoderSDR_build_packet_1_0</sink_block_id><source_key>strobe</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>blocks_random_pdu_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>burst_framer_0</sink_block_id><source_key>pdus</source_key><sink_key>packed_pdus</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>channels_channel_model_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_1</source_block_id><sink_block_id>grnet_tcp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>burst_framer_0</source_block_id><sink_block_id>burst_padder_0</sink_block_id><source_key>unpacked_pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>burst_padder_0</source_block_id><sink_block_id>burst_randomizer_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>burst_preamble_insert_0</source_block_id><sink_block_id>mapper_mapper_msg_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>burst_randomizer_0</source_block_id><sink_block_id>fec_async_encoder_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>burst_scheduler_0</source_block_id><sink_block_id>es_source_0</sink_block_id><source_key>sched_pdu</source_key><sink_key>schedule_event</sink_key></connection>
<connection><source_block_id>burst_scheduler_0</source_block_id><sink_block_id>pyqt_meta_text_output_0</sink_block_id><source_key>sched_pdu</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>channels_channel_model_0_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>es_source_0</source_block_id><sink_block_id>burst_scheduler_0</sink_block_id><source_key>nproduced</source_key><sink_key>nproduced</sink_key></connection>
<connection><source_block_id>es_source_0</source_block_id><sink_block_id>AlteraSocSDR_altera_socfpga_sdr_sink_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>es_source_0</source_block_id><sink_block_id>blocks_throttle_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>es_source_0</source_block_id><sink_block_id>root_raised_cosine_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_async_encoder_0</source_block_id><sink_block_id>burst_preamble_insert_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>mapper_mapper_msg_0</source_block_id><sink_block_id>burst_scheduler_0</sink_block_id><source_key>cpdus</source_key><sink_key>sched_pdu</sink_key></connection>
<connection><source_block_id>mapper_mapper_msg_0</source_block_id><sink_block_id>pyqt_ctime_plot_0</sink_block_id><source_key>cpdus</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>pdu_utils_pack_unpack_0</source_block_id><sink_block_id>fec_async_encoder_0</sink_block_id><source_key>pdu_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
